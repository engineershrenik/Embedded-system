# IAR project ble_demo_tbrx23w_profile_server.ewp, settings and files
configuration HardwareDebug (RX, debug)
  General.OGChipSelectMenu: R5F523W8 R5F523W8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x1000
  General.IStackSize: 0x400
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa050,Pe009,Pe301
  ICCRX.CCIncludePath2: src/smc_gen/Config_BLE_PROFILE; src/smc_gen/r_ble_qe_utility; src/smc_gen/r_config; src/smc_gen/r_ble_rx23w; src/smc_gen/r_ble_rx23w/src; src/smc_gen/r_ble_rx23w/src/app_lib; src/smc_gen/r_ble_rx23w/src/platform; src/smc_gen/r_ble_rx23w/lib; src/smc_gen/general; src/smc_gen/r_byteq; src/smc_gen/r_byteq/src; src/smc_gen/r_flash_rx; src/smc_gen/r_flash_rx/src; src/smc_gen/r_flash_rx/src/flash_type_1; src/smc_gen/r_flash_rx/src/flash_type_3; src/smc_gen/r_flash_rx/src/flash_type_4; src/smc_gen/r_flash_rx/src/targets; src/smc_gen/r_gpio_rx; src/smc_gen/r_gpio_rx/src; src/smc_gen/r_irq_rx; src/smc_gen/r_irq_rx/src; src/smc_gen/r_lpc_rx; src/smc_gen/r_lpc_rx/src; src/smc_gen/r_sci_rx; src/smc_gen/r_sci_rx/src; src/smc_gen/r_bsp; src/smc_gen/r_cmt_rx; src/smc_gen/r_cmt_rx/src; src/smc_gen/r_pincfg
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: ble_demo_tbrx23w_profile_server.srec
  prebuild: src\smc_gen\r_ble_rx23w\lib\ble_fit_lib_selector.bat
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\lnkr5f523w8.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: src/smc_gen/r_ble_rx23w/lib/lib_ble_ps_ccrx.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src
    src/: ble_demo_tbrx23w_profile_server.c
  group src/smc_gen/Config_BLE_PROFILE
    src/smc_gen/Config_BLE_PROFILE/: app_main.c gatt_db.c gatt_db.h r_ble_gapc.c r_ble_gapc.h r_ble_gaps.c r_ble_gaps.h r_ble_gats.c r_ble_gats.h r_ble_lss.c r_ble_lss.h
  group src/smc_gen/general
    src/smc_gen/general/: r_cg_hardware_setup.c r_cg_macrodriver.h r_cg_userdefine.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group src/smc_gen/r_ble_qe_utility
    src/smc_gen/r_ble_qe_utility/: readme.txt
  group src/smc_gen/r_ble_rx23w
    src/smc_gen/r_ble_rx23w/: r_ble_rx23w_if.h readme.txt
  group src/smc_gen/r_ble_rx23w/lib
    src/smc_gen/r_ble_rx23w/lib/: lib_ble_ps_ccrx.lib lib_ble_ps_ccrx_a.lib lib_ble_ps_ccrx_b.lib lib_ble_ps_ccrx_c.lib lib_ble_ps_hci_ccrx.lib lib_ble_ps_hci_ccrx_a.lib lib_ble_ps_hci_ccrx_b.lib lib_ble_ps_hci_ccrx_c.lib
  group src/smc_gen/r_ble_rx23w/ref
    src/smc_gen/r_ble_rx23w/ref/: r_ble_rx23w_config_reference.h
  group src/smc_gen/r_ble_rx23w/src/app_lib/abs
    src/smc_gen/r_ble_rx23w/src/app_lib/abs/: r_ble_abs_api.c r_ble_abs_api.h
  group src/smc_gen/r_ble_rx23w/src/app_lib/board
    src/smc_gen/r_ble_rx23w/src/app_lib/board/: r_ble_board.c r_ble_board.h
  group src/smc_gen/r_ble_rx23w/src/app_lib/cli
    src/smc_gen/r_ble_rx23w/src/app_lib/cli/: r_ble_cli.c r_ble_cli.h
  group src/smc_gen/r_ble_rx23w/src/app_lib/cli/console
    src/smc_gen/r_ble_rx23w/src/app_lib/cli/console/: r_ble_console.h
  group src/smc_gen/r_ble_rx23w/src/app_lib/cli/console/rx_family
    src/smc_gen/r_ble_rx23w/src/app_lib/cli/console/rx_family/: r_ble_console.c
  group src/smc_gen/r_ble_rx23w/src/app_lib/cmd
    src/smc_gen/r_ble_rx23w/src/app_lib/cmd/: r_ble_cmd.c r_ble_cmd.h r_ble_cmd_abs.c r_ble_cmd_abs.h r_ble_cmd_sys.c r_ble_cmd_sys.h r_ble_cmd_vs.c r_ble_cmd_vs.h
  group src/smc_gen/r_ble_rx23w/src/app_lib/discovery
    src/smc_gen/r_ble_rx23w/src/app_lib/discovery/: r_ble_disc.c r_ble_disc.h
  group src/smc_gen/r_ble_rx23w/src/app_lib/logger
    src/smc_gen/r_ble_rx23w/src/app_lib/logger/: r_ble_logger.c r_ble_logger.h
  group src/smc_gen/r_ble_rx23w/src/app_lib/profile_cmn
    src/smc_gen/r_ble_rx23w/src/app_lib/profile_cmn/: r_ble_profile_cmn.h r_ble_serv_common.c r_ble_serv_common.h r_ble_servc_if.c r_ble_servc_if.h r_ble_servs_if.c r_ble_servs_if.h
  group src/smc_gen/r_ble_rx23w/src/app_lib/sec_data
    src/smc_gen/r_ble_rx23w/src/app_lib/sec_data/: r_ble_sec_data.c r_ble_sec_data.h
  group src/smc_gen/r_ble_rx23w/src/app_lib/timer
    src/smc_gen/r_ble_rx23w/src/app_lib/timer/: r_ble_timer.c r_ble_timer.h r_ble_timer_rx23w.c
  group src/smc_gen/r_ble_rx23w/src/platform
    src/smc_gen/r_ble_rx23w/src/platform/: r_ble_pf_config_private.h r_ble_pf_configs.c r_ble_pf_functions.c r_ble_pf_lowpower.c
  group src/smc_gen/r_ble_rx23w/src/platform/driver/dataflash
    src/smc_gen/r_ble_rx23w/src/platform/driver/dataflash/: r_ble_dataflash.c
  group src/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group src/smc_gen/r_bsp/board/generic_rx23w
    src/smc_gen/r_bsp/board/generic_rx23w/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h
  group src/smc_gen/r_bsp/board/user
    src/smc_gen/r_bsp/board/user/: r_bsp.h
  group src/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: dbsct.c lowlvl.c lowlvl.h lowsrc.c lowsrc.h mcu_locks.c r_bsp_common.c r_bsp_common.h r_bsp_cpu.c r_bsp_interrupts.c r_bsp_interrupts.h r_bsp_locking.c r_bsp_mcu_startup.c r_bsp_mcu_startup.h r_bsp_software_interrupt.c r_bsp_software_interrupt.h r_rtos.h r_rx_compiler.h r_rx_intrinsic_functions.c r_rx_intrinsic_functions.h r_typedefs.h resetprg.c sbrk.c sbrk.h
  group src/smc_gen/r_bsp/mcu/rx23w
    src/smc_gen/r_bsp/mcu/rx23w/: mcu_clocks.c mcu_clocks.h mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.h r_bsp_clock.c r_bsp_clock.h r_bsp_cpu.h r_bsp_locking.h r_bsp_vbatt.c r_bsp_vbatt.h vecttbl.c vecttbl.h
  group src/smc_gen/r_bsp/mcu/rx23w/register_access/ccrx
    src/smc_gen/r_bsp/mcu/rx23w/register_access/ccrx/: iodefine.h
  group src/smc_gen/r_bsp/mcu/rx23w/register_access/iccrx
    src/smc_gen/r_bsp/mcu/rx23w/register_access/iccrx/: iodefine.h
  group src/smc_gen/r_byteq
    src/smc_gen/r_byteq/: r_byteq_if.h readme.txt
  group src/smc_gen/r_byteq/ref
    src/smc_gen/r_byteq/ref/: r_byteq_config_reference.h
  group src/smc_gen/r_byteq/src
    src/smc_gen/r_byteq/src/: r_byteq.c r_byteq_private.h
  group src/smc_gen/r_cmt_rx
    src/smc_gen/r_cmt_rx/: r_cmt_rx_if.h readme.txt
  group src/smc_gen/r_cmt_rx/ref
    src/smc_gen/r_cmt_rx/ref/: r_cmt_rx_config_reference.h
  group src/smc_gen/r_cmt_rx/src
    src/smc_gen/r_cmt_rx/src/: r_cmt_rx.c
  group src/smc_gen/r_config
    src/smc_gen/r_config/: r_ble_rx23w_config.h r_bsp_config.h r_bsp_config_readme.txt r_byteq_config.h r_cmt_rx_config.h r_flash_rx_config.h r_gpio_rx_config.h r_irq_rx_config.h r_lpc_rx_config.h r_sci_rx_config.h
  group src/smc_gen/r_flash_rx
    src/smc_gen/r_flash_rx/: r_flash_rx_if.h readme.txt
  group src/smc_gen/r_flash_rx/ref
    src/smc_gen/r_flash_rx/ref/: r_flash_rx_config_reference.h
  group src/smc_gen/r_flash_rx/src
    src/smc_gen/r_flash_rx/src/: r_flash_fcu.c r_flash_fcu.h r_flash_group.c r_flash_group.h r_flash_rx.c r_flash_rx.h r_flash_targets.h
  group src/smc_gen/r_flash_rx/src/flash_type_1
    src/smc_gen/r_flash_rx/src/flash_type_1/: r_codeflash.c r_codeflash.h r_codeflash_extra.c r_codeflash_extra.h r_dataflash.c r_dataflash.h r_flash_common.h r_flash_type1.c r_flash_type1_if.h r_flash_utils.c
  group src/smc_gen/r_flash_rx/src/flash_type_3
    src/smc_gen/r_flash_rx/src/flash_type_3/: r_flash_type3.c r_flash_type3_if.h
  group src/smc_gen/r_flash_rx/src/flash_type_4
    src/smc_gen/r_flash_rx/src/flash_type_4/: r_flash_type4.c r_flash_type4_if.h
  group src/smc_gen/r_flash_rx/src/targets/rx23w
    src/smc_gen/r_flash_rx/src/targets/rx23w/: r_flash_rx23w.h
  group src/smc_gen/r_gpio_rx
    src/smc_gen/r_gpio_rx/: r_gpio_rx_if.h readme.txt
  group src/smc_gen/r_gpio_rx/ref
    src/smc_gen/r_gpio_rx/ref/: r_gpio_rx_config_reference.h
  group src/smc_gen/r_gpio_rx/src
    src/smc_gen/r_gpio_rx/src/: r_gpio_rx.c
  group src/smc_gen/r_gpio_rx/src/targets/rx23w
    src/smc_gen/r_gpio_rx/src/targets/rx23w/: r_gpio_rx23w.c r_gpio_rx23w.h
  group src/smc_gen/r_irq_rx
    src/smc_gen/r_irq_rx/: r_irq_rx_if.h readme.txt
  group src/smc_gen/r_irq_rx/ref
    src/smc_gen/r_irq_rx/ref/: r_irq_rx_config_reference.h
  group src/smc_gen/r_irq_rx/src
    src/smc_gen/r_irq_rx/src/: r_irq_rx.c r_irq_rx_private.h
  group src/smc_gen/r_lpc_rx
    src/smc_gen/r_lpc_rx/: r_lpc_rx_if.h readme.txt
  group src/smc_gen/r_lpc_rx/ref
    src/smc_gen/r_lpc_rx/ref/: r_lpc_rx_config_reference.h
  group src/smc_gen/r_lpc_rx/src
    src/smc_gen/r_lpc_rx/src/: r_lpc_rx.c r_lpc_rx_platform.h r_lpc_rx_private.h
  group src/smc_gen/r_lpc_rx/src/targets/rx23w
    src/smc_gen/r_lpc_rx/src/targets/rx23w/: r_lpc_rx23w.c r_lpc_rx23w_if.h r_lpc_rx23w_private.h
  group src/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h r_irq_rx_pinset.c r_irq_rx_pinset.h r_pinset.h r_sci_rx_pinset.c r_sci_rx_pinset.h
  group src/smc_gen/r_sci_rx
    src/smc_gen/r_sci_rx/: r_sci_rx_if.h readme.txt
  group src/smc_gen/r_sci_rx/ref
    src/smc_gen/r_sci_rx/ref/: r_sci_rx_config_reference.h
  group src/smc_gen/r_sci_rx/src
    src/smc_gen/r_sci_rx/src/: r_sci_rx.c r_sci_rx_dmaca.c r_sci_rx_dmaca.h r_sci_rx_dtc.c r_sci_rx_dtc.h r_sci_rx_platform.h r_sci_rx_private.h
  group src/smc_gen/r_sci_rx/src/targets/rx23w
    src/smc_gen/r_sci_rx/src/targets/rx23w/: r_sci_rx23w.c r_sci_rx23w_data.c r_sci_rx23w_private.h
